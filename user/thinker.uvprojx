# Keil uVision project thinker.uvprojx, settings and files
target thinker (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: thinker +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\core;..\driver\inc;..\ucos;..\user;..\tools\inc;..\device\button;..\device\lcd;..\device\led;..\ucos\uC-CPU\ARM-Cortex-M3;..\ucos\uC-LIB;..\ucos\UCOS_BSP;..\ucos\UCOS_CONFIG;..\ucos\uCOS-III;..\ucos\uCOS-III\Ports;..\ucos\uCOS-III\Source;..\ucos\uC-LIB\Ports;..\ucos\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\ucos\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\ucos\uC-CPU\ARM-Cortex-M3\RealView;..\ucos\uC-CPU;..\services;..\device;..\device\esp8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../app/: main.c
  group core
    ../core/: startup_stm32f10x_hd.s system_stm32f10x.c stm32f10x_it.c
  group driver
    ../driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_wwdg.c
  group device
    ../device/button/: button.c
    ../device/lcd/: lcd.c
    ../device/led/: led.c
    ../device/esp8266/: esp8266.c esp8266_driver.c
  group tools
    ../tools/src/: heartbeat.c uart.c log.c
  group ucosiii
    ../ucos/UCOS_BSP/: bsp.c
    ../ucos/uC-CPU/: cpu_core.c
    ../ucos/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../ucos/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../ucos/uCOS-III/Ports/: os_cpu_a.s os_cpu_c.c
    ../ucos/UCOS_CONFIG/: os_app_hooks.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
    ../ucos/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm
    ../ucos/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
    ../ucos/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h
  group services
    ../services/: services.c
  group doc
    ../doc/: 工程说明.txt
software components: CMSIS:CORE 5.1.2
